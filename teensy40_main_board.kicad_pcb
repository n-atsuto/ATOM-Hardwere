# Repository n-atsuto/ATOM-Hardwere

## KiCad design teensy40_main_board.kicad_pcb

Parts:
BZ1: Buzzer; ブザー (mb series)
C1, C10: 100~220µF; CP_Elec_6.3x7.7
C2, C3, C4, C6, C8, C11: 0.1µF; C_0805_2012Metric
C5, C7, C9: 10µF; C_0805_2012Metric
C12: C; CP_Radial_D5.0mm_P2.50mm
D2, D20: SMBJ5.0A; D_SMB
J1, J3: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: Conn_02x05_Counter_Clockwise; IDC-Header_2x05_P2.54mm_Vertical
J4: 1-To_Control_Board; IDC-Header_2x07_P2.54mm_Vertical
J5: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: To_interconnect_board; IDC-Header_2x07_P2.54mm_Vertical
Q1: STD30NF06LT4; DPAK_STM
R3: 220Ω; R_0805_2012Metric
R4: 10kΩ; R_0805_2012Metric
SW1: SW_SPDT; 基板用トグルスイッチ
U2: GREEN BNO055
U3: Twelite
U4: teensy4.0(breakout board in); teensy40(breakout)
U6: communication module
U14: BLUE BNO055

Connections:
+3V3: C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, D20.1 (A1), J1.2, SW1.3 (C), U2.1 (VIN(5V)), U3.6 (VCC), U6.8 (LOGV), U14.1 (VIN)
+5V: C1.1, C2.2, C3.2, D2.1 (A1), J1.4, J3.4, U4.33 (VIN)
+12V: C12.1, J1.1, U6.7 (VIN)
/01: U4.45 (34_DAT1_MISO2), U6.2 (01)
/02: U4.46 (35_DAT0_MOSI2), U6.1 (02)
/Atack_Color: J2.6, U4.48 (36_CLK_CS2)
/Catch_Sensor: J5.1, J6.8, U4.13 (11_MOSI_CTX1)
/Charge_FET: J6.10, U4.12 (10_CS_MQSR)
/Comm_RX: U4.9 (7_RX2_OUT1A), U6.4 (TX)
/Comm_TX: U4.10 (8_TX2_IN1), U6.3 (RX)
/DRIB1_PWM: J6.3, U4.6 (4_BCLK2)
/Fan1_GND: J6.1, Q1.2 (D)
/Fan1_PWM: R3.1, U4.5 (3_LRCLK2)
/IR_RX: J4.11, U4.22 (15_A1_RX3_SPDIF_IN)
/IR_TX: J4.12, U4.21 (14_A0_TX3_SPDIF_OUT)
/IR_direct: J4.13, U4.38 (27_A13_SCK1)
/Kick_FET: J6.12, U4.11 (9_OUT1C)
/Line_NeoPixel: J6.6, U4.14 (12_MISO_MQSL)
/Line_RX: J6.14, U4.35 (24_A10_TX6_SCL2)
/Line_TX: J6.13, U4.36 (25_A11_RX6_SDA2)
/Line_direct: J6.7, U4.37 (26_A12_MOSI1)
/MD_RX: J3.1, J6.4, U4.2 (0_RX1_CRX2_CS1)
/MD_TX: J3.2, J6.2, U4.3 (1_TX1_CTX2_MISO1)
/OpenMV_RX: J4.9, U4.23 (16_A2_RX4_SCL1)
/OpenMV_TX: J4.10, U4.24 (17_A3_TX4_SDA1)
/SCL: J2.10, U2.4 (SCL/RX), U4.26 (19_A5_SCL0), U14.4 (SDA/TX)
/SDA: J2.9, U2.3 (SDA/TX), U4.25 (18_A4_SDA0), U14.3 (SCL/RX)
/SW_GyroReset: J2.5, U4.29 (22_A8_CTX1)
/SW_left: J2.2, U4.52 (39_DAT2_TX5)
/SW_right: J2.1, U4.50 (37_CMD_SCK2)
/SW_run: J2.4, U4.51 (38_DAT3_RX5)
/Sonic_Echo1: J4.4, U4.44 (33_MCLK2)
/Sonic_Echo2: J4.6, U4.43 (32_OUT1B)
/Sonic_Echo3: J4.2, U4.42 (31_CTX3)
/Sonic_Echo4: J4.8, U4.41 (30_CRX3)
/Sonic_Trig: J4.7, U4.7 (5_IN2)
/SubMCU_RX: J2.8, U4.28 (21_A7_RX5_BCLK1)
/SubMCU_TX: J2.7, U4.27 (20_A6_TX5_LRCLK1)
/Twe_RX: U3.4 (RX), U4.39 (28_RX7)
/Twe_TX: U3.2 (TX), U4.40 (29_TX7)
/Visual_NeoPixel: J4.5, U4.8 (6_OUT1D)
/start: SW1.2 (B), U4.30 (23_A9_CRX1_MCLK1)
GND: BZ1.2 (+), C1.2, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.2, C11.1, C12.2, D2.2 (A2), D20.2 (A2), J1.3, J3.3, J4.14, J5.2, Q1.3 (S), R4.1, SW1.1 (A), U2.2 (GND), U2.7 (GND), U3.1 (GND), U4.1 (GND), U4.17 (GND), U4.32 (GND), U4.47 (GND), U6.10 (GND), U14.2 (GND)
unnamed: BZ1.1 (-), U4.4 (2_OUT2)
unnamed: Q1.1 (G), R3.2, R4.2
teensy+3V3: J2.3, J4.1, J6.5, U4.31 (3V3)

Notes on the sheet:
GREEN BNO 055
Twelite
BLUE BNO 055
DALTON-Max-main board
FAN
out
connectors
回路・IC保護
Modules
sendors
main unit

Board: 2 copper layers, 70.2 x 91.5 mm, 30 parts (0 on the bottom side), 46 nets.
